# Autodesk Inventor part: Sheet Metal (mm)
## iProperties
Created: 2007-03
Part Number: Sheet Metal (mm)
Document SubType Name: Sheet Metal
Designer: anchalk
Density: 1 g/cm^3
Author: anchalk
