# Autodesk Inventor part: Sheet Metal (in)
## iProperties
Created: 2007-03
Part Number: Sheet Metal (in)
Document SubType Name: Sheet Metal
Designer: anchalk
Density: 1 g/cm^3
Author: anchalk
