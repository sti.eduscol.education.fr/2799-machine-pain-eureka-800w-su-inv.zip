# Autodesk Inventor assembly: machine_a_pain
## iProperties
Created: 2010-12
Part Number: machine_a_pain
Document SubType Name: Assembly
Designer: eric
Author: eric
